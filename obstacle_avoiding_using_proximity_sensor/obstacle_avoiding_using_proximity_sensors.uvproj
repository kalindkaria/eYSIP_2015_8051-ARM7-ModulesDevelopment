# Keil uVision project obstacle_avoiding_using_proximity_sensors.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: obstacle_avoiding_using_proximity_sensors +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: obstacle_avoiding_using_proximity_sensors.c lcd_display.h p89v51rx2.H
