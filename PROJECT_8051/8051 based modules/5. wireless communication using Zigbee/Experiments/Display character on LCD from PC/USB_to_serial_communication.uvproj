# Keil uVision project USB_to_serial_communication.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: USB_to_serial_communication +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: USB_to_serial_communication.c lcd_display.h p89v51rx2.H
