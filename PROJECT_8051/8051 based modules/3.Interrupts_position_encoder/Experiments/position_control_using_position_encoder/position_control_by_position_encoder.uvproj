# Keil uVision project position_control_by_position_encoder.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: position_control_by_position_encoder +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: p89v51rx2.H lcd_display.h position_encoder.c
