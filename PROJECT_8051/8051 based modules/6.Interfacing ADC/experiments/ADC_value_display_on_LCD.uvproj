# Keil uVision project ADC_value_display_on_LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: ADC_value_display_on_LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ADC_value_display_on_LCD.c delay_ms.h lcd_display.h p89v51rx2.H
