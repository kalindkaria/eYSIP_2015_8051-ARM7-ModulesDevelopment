# Keil uVision project 90_degree_right_turn.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: 90_degree_right_turn +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 90_degree_right_turn_using_position_encoder.c p89v51rx2.H delay_ms.h
