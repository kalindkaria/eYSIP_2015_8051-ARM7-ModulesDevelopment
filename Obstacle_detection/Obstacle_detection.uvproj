# Keil uVision project Obstacle_detection.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89LV51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: Obstacle_detection +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Obstacle_detection_using_sharpIR_sensor.c lcd_display.h p89v51rx2.H
