# Keil uVision project Battery_voltage_sensing.uvproj, settings and files
target Target 1 (MCS-51)
  device: P89V51RD2 NXP (founded by Philips)
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: Battery_voltage_sensing +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Battery_voltage_sensing.c lcd_display.h p89v51rx2.H
